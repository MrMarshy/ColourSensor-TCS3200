# Keil uVision project Keil-ReadRGBColours.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Keil-ReadRGBColours
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CLOCK_SETUP=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: main.c accel.h accel.c common.h delay.c pulse_measure.h pulse_measure.c uart.h uart.c ring.h ring.c tinyprintf.h tinyprintf.c TCS320.h
software components: CMSIS:CORE 5.4.0, Compiler:Event Recorder 1.4.0, Device:Startup 2.5.0
